# Keil uVision project demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: D:\stm32\project\手柄\USER;D:\stm32\project\手柄\CORE;D:\stm32\project\手柄\HARDWARE;D:\stm32\project\手柄\USB;D:\stm32\project\手柄\Libraries\STM32F10x_FWLib\inc;D:\stm32\project\手柄\Libraries\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    D:/stm32/project/手柄/USER/: main.c
  group HARDWARE
    D:/stm32/project/手柄/HARDWARE/: usart.c adc.c joystick.c delay.c oled.c menu.c flash_save.c boot_splash.c boot_splash_data.c
  group CORE
    D:/stm32/project/手柄/CORE/: core_cm3.c
  group FWLib
    D:/stm32/project/手柄/Libraries/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_exti.c
  group USB_Driver
    D:/stm32/project/手柄/Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB
    D:/stm32/project/手柄/USB/: usb_desc.c usb_prop.c usb_pwr.c usb_istr.c usb_endp.c hw_config.c usb_it.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
